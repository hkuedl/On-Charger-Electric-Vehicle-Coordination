# Keil uVision project G4.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G474CETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: G4 +hex
  c flags: oTime=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G474xx,HAL_HRTIM_MODULE_ENABLED,
  c include: ..\HAL_lib;..\HAL_lib\Inc;..\HAL_lib\Src;..\MDK;..\mycode;..\Output;..\User_code;..\DSP_Lib;..\DSP_Lib\include;..\mycode
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\STM32G4.sct
  group HAL_lib
    ../HAL_lib/Src/: stm32g4xx_hal.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_exti.c stm32g4xx_hal_gpio.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_rtc.c stm32g4xx_hal_rtc_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal_usart.c stm32g4xx_hal_usart_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_iwdg.c stm32g4xx_hal_wwdg.c stm32g4xx_hal_dac.c stm32g4xx_hal_dac_ex.c stm32g4xx_hal_comp.c stm32g4xx_hal_hrtim.c stm32g4xx_hal_cordic.c stm32g4xx_hal_opamp.c stm32g4xx_hal_opamp_ex.c stm32g4xx_hal_rng.c
  group MDK
    ../MDK/: cmsis_armcc.h core_cm4.h startup_stm32g474xx.s
    ./: stm32g474xx.h
  group mycode
    ../mycode/: clock_config.c Delay.c Int.c ADC.c HRTIM.c state_machine.c RGB.c type3.c oled.c data.c Optimization.c usart.c
  group User_code
    ./: main.c stm32g4xx_hal_msp.c stm32g4xx_it.c system_stm32g4xx.c stm32g4xx_nucleo.c
